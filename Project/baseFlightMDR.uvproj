# Keil uVision project baseFlightMDR.uvproj, settings and files
target BaseFlight (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MDR32F9Q2I Milandr
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: baseFlightMDR +hex
  c flags: uC99=1 v6Lang=1 v6LangP=1
  c define: NAZE
  c misc: --c99
  c include: ..\CMSIS\CoreSupport;..\CMSIS\DeviceSupport\MDR32F9Qx\inc;..\MDR32F9Qx_SPL;..\Source;..\StartUp;..\CMSIS\DeviceSupport\MDR32F9Qx\startup\arm;..\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group StartUp
    ../StartUp/: startup_MDR32F9x.s
  group Source
    ../Source/: main.c config.c eeprom.c drv_system.c can.c UART.c mw.c drv_i2c.c drv_gpio.c drv_adc.c sensors.c utils.c drv_mpu.c board.h mw.h can.h define.h drv_adc.h drv_gpio.h drv_i2c.h drv_mpu.h drv_system.h eeprom.h protocol.h UART.h utils.h imu.c mixer.c drv_uart.c drv_uart.h drv_serial.h drv_pwm.c drv_pwm.h drv_timer.h drv_timer.c serial.c drv_serial.c gps.c rxmsp.c drv_hmc5883l.c drv_hmc5883l.h drv_qmc5883l.c drv_qmc5883l.h
  group CMSIS
    ../CMSIS/: MDR32F9Qx_config.h
    ../CMSIS/CoreSupport/: core_cm3.h core_cmFunc.h core_cmInstr.h
    ../CMSIS/DeviceSupport/MDR32F9Qx/inc/: MDR32Fx.h
    ../CMSIS/DeviceSupport/MDR32F9Qx/startup/arm/: system_MDR32F9Qx.c system_MDR32F9Qx.h
  group SPL
    ../MDR32F9Qx_SPL/: MDR32F9Qx_eeprom.c MDR32F9Qx_eeprom.h MDR32F9Qx_rst_clk.c MDR32F9Qx_rst_clk.h MDR32F9Qx_port.c MDR32F9Qx_port.h MDR32F9Qx_can.c MDR32F9Qx_can.h MDR32F9Qx_uart.c MDR32F9Qx_i2c.c MDR32F9Qx_adc.c MDR32F9Qx_dma.c MDR32F9Qx_timer.h MDR32F9Qx_timer.c
